;ESTE PROGRAMA IMPLEMENTE UNA BUSQUETA BINARIA EN UNA ARRAY
;EL ARRAY TIENE QUE ESTAR ORDENADO DE MANERA ASCENDENTE
		
		;AREA DE DATOS
		AREA myDATA,DATA,READONLY,ALIGN=2
array	DCD	11,12,13,14,15,16
size	DCD	6
		
		;AREA DE CODIGO
		AREA myCODE,CODE,READONLY,ALIGN=2
		EXPORT	__main
		ENTRY
__main	PROC
		MOVS	R3,#14		;NUMERO QUE SE VA BUSCAR EN EL ARRAY
		MOVS	R5,#-1		;LOCACION
		LDR		R12,=array
		ALIGN
		MOVS	R1,#0		;R1 = LEFT
		
		LDR		R2,=size
		ALIGN
		LDR		R2,[R2]		;LE LEE EL TAMAСO DEL ARRAY
		SUB		R2,R2,#1	;R2	= RIGHT
		
loop	ADD		R0,R1,R2	;R0 = LEFT + RIGHT
		LSR		R0,R0, #1
		LDR		R4,[R12,R0,LSL #2];ARRAY MIDDLE
		
		CMP		R4,R3
		SUBGT	R2,R0,#1	;RIGHT = MIDDLE - 1
		ADDLT	R1,R0,#1	;LEFT = MIDDLE + 1
		BEQ		found
		
		CMP 	R1,R2		;COMPARA LEFT Y RIGHT
		BLE		loop
found	MOVEQ 	R5,R0

stop	B		stop
	
		ENDP
		END